options:
  parameters:
    generate_options: qt_gui
    id: dvbs_tx_test2
    output_language: python
    title: DVBS_TX
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 30e6
    step: 100e3
    stop: 80e6
    value: 55e6
    widget: counter
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ce/labvid1M_qpsk_5to6aOFF.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: byte
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_ON
    rate1: C5_6
  states: {}
- name: dtv_dvbt_convolutional_interleaver_0
  id: dtv_dvbt_convolutional_interleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_energy_dispersal_0
  id: dtv_dvbt_energy_dispersal
  parameters:
    nsize: '1'
  states: {}
- name: dtv_dvbt_inner_coder_0
  id: dtv_dvbt_inner_coder
  parameters:
    code_rate: C5_6
    constellation: qpsk
    hierarchy: nh
    ninput: '1'
    noutput: '1512'
  states: {}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, 0.35, rrc_taps)
    type: ccc
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '0'
    if_gain0: '46'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: qpskmod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: qpskmod
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_dvbt_energy_dispersal_0, '0']
- [blocks_vector_to_stream_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', virtual_sink_0, '0']
- [dtv_dvbt_convolutional_interleaver_0, '0', dtv_dvbt_inner_coder_0, '0']
- [dtv_dvbt_energy_dispersal_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [dtv_dvbt_inner_coder_0, '0', blocks_vector_to_stream_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', dtv_dvbt_convolutional_interleaver_0, '0']
- [fft_filter_xxx_0, '0', osmosdr_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [virtual_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
